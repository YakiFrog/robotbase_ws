Commit message: chore: update robot dimensions, update nav2 footprints, and add PreferForward cost critic

File: src/robotbase_bringup/urdf/robotbase.urdf (robot description, URDF)
Before this commit: robot koko, 8 links, 7 joints
Links:
- link base_link: geometry visual box size=0.90 0.66 0.28
